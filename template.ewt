<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\CMSIS\src\startup_efm32gg.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\src\system_efm32gg.c</name>
    </file>
  </group>
  <group>
    <name>emlib</name>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_acmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_assert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_burtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_cmu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_dbg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_ebi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_emu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_idac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_lesense.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_letimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_leuart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_mpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_msc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_opamp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_pcnt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_prs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_rmu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_system.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_vcmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\emlib\src\em_wdog.c</name>
    </file>
  </group>
  <group>
    <name>source</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
  </group>
</project>


